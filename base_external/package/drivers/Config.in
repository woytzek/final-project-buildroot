## base_external/package/drivers/Config.in
```kconfig
config BR2_PACKAGE_DRIVERS
	bool "drivers"
	help
	  Includes device drivers for final project
```
